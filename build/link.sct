LR_IROM1 0x0800A000 0x00036000 {
  ER_IROM1 0x0800A000 0x00036000 {
    *.o (RESET, +First)
    *(InRoot$$Sections)
    .ANY (+RO)
  }
  RW_IRAM1 0x20000000 0x00030000 {
    .ANY (+RW +ZI)
  }
}
